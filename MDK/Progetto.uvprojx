# Keil uVision project Progetto.uvprojx, settings and files
target Target 1 (6160000::V6.16::ARMCLANG)
  device: STM32L476VGTx STMicroelectronics
  pack: Keil.STM32L4xx_DFP.2.6.1
  cpu: IRAM(0x20000000,0x00018000) IRAM2(0x10000000,0x00008000) IROM(0x08000000,0x00100000) CPUTYPE("Cortex-M4") FPU2 DSP CLOCK(12000000) ELITTLE
  output: Progetto
  c flags: Optim=2 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x18000
  memory RVCT10: RAM 0x10000000 size 0x8000
  group Source Group 1
    ../: AppSensoreParcheggio.c interrupt.c interrupt.h LCD.c LCD.h led.c led.h main.c puls.c puls.h SysClock.c SysClock.h SysTick.c Ultrasuoni.c Ultrasuoni.h
software components: CMSIS:CORE 5.5.0, Device:Startup 1.3.1
